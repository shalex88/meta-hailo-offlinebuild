require conf/include/use-offline-build.inc